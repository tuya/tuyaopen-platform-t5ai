# Keil uVision project bk_bootloader_up.uvproj, settings and files
target target (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk_bootloader_up
  AfterMake: fromelf  #L --bin --output bk_bootloader_up.bin
  AfterMake: generate.bat
  c flags: Optim=2 OneElfS=1 wLevel=2
  c misc: --c99
  c include: ..\system;..\drivers;..\packages\rt_ota_lib\inc;..\components\rt_ota;..\applications;..\packages\quicklz;..\packages\tinycrypt\include;..\packages\fal\inc;..\components\fal;..\packages\xz_ota_lib;..\packages\sb
  memory RVCT1: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x400000 size 0x8000
  scatter file: .\lnk\BK7271.sct
  link misc: --entry 0x1F00
  group asm
    ../system/asm/: boot_vectors.s boot_handlers.s
    ./lnk/: BK7211.sct
  group app
    ../applications/: app_jump.c main.c ota.c bootx.c crc16.c encrypt.c abc.c
  group driver
    ../drivers/: driver_flash.c driver_gpio.c driver_icu.c driver_uart0.c driver_uart1.c driver_uart2.c board.c drv_uart.c drv_pwm.c drv_timer.c
  group system
    ../system/: BK_System.c interrupt.c heap.c
  group rt_ota
    ../components/rt_ota/: rt_ota_key_port.c
    ../packages/rt_ota_lib/libs/: librt_ota_0.2.4_arm968e-s_keil.lib
  group quicklz
    ../packages/quicklz/: quicklz.c
  group tinycrypt
    ../packages/tinycrypt/src/: tiny_aes.c
  group fal
    ../packages/fal/src/: fal.c fal_flash.c fal_partition.c
    ../components/fal/: fal_flash_beken7231_crc_port.c fal_flash_beken7231_port.c
  group libz
    ../packages/libz/: libz.lib
    ../packages/xz_ota_lib/: OTA_XZ.lib
  group secrue
    ../packages/sb/: sb_utility.c SB_Lib.lib
